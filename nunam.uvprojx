# Keil uVision project nunam.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.30.2
  cpu: IRAM(0x20000000,0x00006000) IRAM2(0x00800000,0x00006000) IROM(0x00000000,0x00030000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: nunam
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x800000 size 0x6000
  group Source Group 1
    ./: main.c
software components: CMSIS Driver Validation:Framework 2.0.0, CMSIS Driver Validation:USART 1.4.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.13.0, Device:Startup 8.30.2
